# IAR project mfb_fw.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1042xxx5B NXP MIMXRT1042xxx5B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1042XJM5B; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../src; ../../../../../devices/MIMXRT1042/utilities/debug_console_lite; ../../../../../devices/MIMXRT1042/drivers; ../../../../../devices/MIMXRT1042; ../../../../../components/uart; ../../../../../components/lists; ../../../../../devices/MIMXRT1042/xip; ../../../xip; ../../../../../components/silicon_id; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MIMXRT1042xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1042XJM5B; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1042xxxxx_flexspi_nor.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1042XJM5B; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1042XJM5B; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1042xxxxx_flexspi_nor.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
    ../../imxrt1021/: port_mixspi_info.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/silicon_id
    ../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../../../../devices/MIMXRT1042/: fsl_device_registers.h MIMXRT1042.h MIMXRT1042_features.h system_MIMXRT1042.c system_MIMXRT1042.h
  group drivers
    ../../../../../devices/MIMXRT1042/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h
  group source
    ../: main.c
    ../../src/: mfb.c mfb.h mfb_adapter.h mfb_config.h mfb_define.h mfb_flexspi_nor_ops.c mfb_nor_flash.c mfb_nor_flash.h mfb_nor_flash_adesto.c mfb_nor_flash_adesto.h mfb_nor_flash_gigadevice.c mfb_nor_flash_gigadevice.h mfb_nor_flash_issi.c mfb_nor_flash_issi.h mfb_nor_flash_micron.c mfb_nor_flash_micron.h mfb_nor_flash_mxic.c mfb_nor_flash_mxic.h mfb_nor_flash_spansion.c mfb_nor_flash_spansion.h mfb_nor_flash_winbond.c mfb_nor_flash_winbond.h microseconds_common.c microseconds_cortexm_systick.c
  group startup
    ../../../../../devices/MIMXRT1042/iar/: startup_MIMXRT1042.s
  group utilities
    ../../../../../devices/MIMXRT1042/utilities/debug_console_lite/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
  group xip
    ../../../xip/: flexspi_nor_config.h flexspi_nor_config_1bit_spi.c
    ../../../../../devices/MIMXRT1042/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
