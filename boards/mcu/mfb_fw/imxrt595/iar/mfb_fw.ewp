# IAR project mfb_fw.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../src; ../../../../../devices/MIMXRT595S/drivers; ../../../../../devices/MIMXRT595S; ../../../../../devices/MIMXRT595S/utilities/debug_console_lite; ../../../../../components/uart; ../../../../../components/lists; ../../../flash_config; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: mfp_fw.srec
  ILINK.IlinkOutputFile: mfp_fw.out
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT595SFFOC_cm33; MCUXPRESSO_SDK
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h port_mixspi_info.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group device
    ../../../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group drivers
    ../../../../../devices/MIMXRT595S/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.c fsl_flexcomm.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_iap.c fsl_iap.h fsl_iopctl.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
  group flash_config
    ../../../flash_config/: evkmimxrt595_flash_config.c evkmimxrt595_flash_config.h
  group source
    ../: main.c
    ../../src/: mfb.c mfb.h mfb_adapter.h mfb_config.h mfb_define.h mfb_flexspi_nor_ops.c mfb_nor_flash.c mfb_nor_flash.h mfb_nor_flash_adesto.c mfb_nor_flash_adesto.h mfb_nor_flash_gigadevice.c mfb_nor_flash_gigadevice.h mfb_nor_flash_issi.c mfb_nor_flash_issi.h mfb_nor_flash_micron.c mfb_nor_flash_micron.h mfb_nor_flash_mxic.c mfb_nor_flash_mxic.h mfb_nor_flash_spansion.c mfb_nor_flash_spansion.h mfb_nor_flash_winbond.c mfb_nor_flash_winbond.h microseconds_common.c microseconds_cortexm_systick.c
  group startup
    ../../../../../devices/MIMXRT595S/iar/: startup_MIMXRT595S_cm33.s
  group utilities
    ../../../../../devices/MIMXRT595S/utilities/debug_console_lite/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
